Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-03-12T14:44:01
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190507_1515(x64) - Exporter 17.0.517.0 - Alternate UI 17.15.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 12 14:44:01 2021 * Host: URD0672 * Database: C:\Users\ZNLDNI01\AppData\Local\Temp\{620A3CC8-DAB9-4451-B28F-55317C2EB112}\ifc * Database version: 5507 * Database creation date: Fri Mar 12 14:43:59 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 12 14:43:59 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 12 14:43:59 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Livello 1
LongName: Livello 1; Elevation: 0 mm

# IfcBuildingElementProxy: IP_Alpha_video push button entry panel_1R_4M, IP_Alpha_video push button entry panel_1R_4M:IP_Alpha_video push button entry panel_1R_4M:146748
In: Livello 1
Type - Classification: IP_Alpha_video push button entry panel_1R_4M (Uniformat)
Pset_BuildingElementProxyCommon - Reference: IP_Alpha_video push button entry panel_1R_4M
Pset_ManufacturerTypeInformation - Manufacturer: Urmet S.p.A. Urmet S.p.A.
